<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>directory</value></param>
<param><key>value</key><value>gui_directory</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fft_size</value></param>
<param><key>value</key><value>gui_fft_size</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>freq_min+(samp_rate/2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_max</value></param>
<param><key>value</key><value>gui_freq_max</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_min</value></param>
<param><key>value</key><value>gui_freq_min</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>gui_directory</value></param>
<param><key>value</key><value>"/home/eamedina/Documentos/freq_docs/fft"</value></param>
<param><key>label</key><value>Directory</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>gui_fft_size</value></param>
<param><key>value</key><value>1024</value></param>
<param><key>label</key><value>FFT size</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1024</value></param>
<param><key>option1</key><value>2048</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_freq_max</value></param>
<param><key>value</key><value>gui_freq_min+samp_rate/1e6</value></param>
<param><key>label</key><value>Higher Frequency (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>gui_freq_min+samp_rate/1e6</value></param>
<param><key>step</key><value>samp_rate/1e6</value></param>
<param><key>stop</key><value>6000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_freq_min</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Lower Frequency (MHz)</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>samp_rate/1e6</value></param>
<param><key>stop</key><value>6000-samp_rate/1e6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>gui_mode</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label0</key><value>Percentage (%)</value></param>
<param><key>label1</key><value>Value (db)</value></param>
<param><key>label</key><value>Mode</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>1</value></param>
<param><key>option1</key><value>2</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gui_mode_value</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value>Mode Value (% or db)</value></param>
<param><key>min_len</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>gui_samp_rate</value></param>
<param><key>value</key><value>20</value></param>
<param><key>label0</key><value>10 Msps</value></param>
<param><key>label1</key><value>20 Msps</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>10</value></param>
<param><key>option1</key><value>20</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_push_button</key>
<param><key>id</key><value>gui_update_btn</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Update Params</value></param>
<param><key>pressed</key><value>1</value></param>
<param><key>released</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>gui_samp_rate*1e6</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>variable_qtgui_chooser_0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label0</key><value>433 MHz</value></param>
<param><key>label1</key><value>868 MHz</value></param>
<param><key>label2</key><value>Wifi 2.4GHz</value></param>
<param><key>label3</key><value>Wifi 5.8 GHz</value></param>
<param><key>label4</key><value>GPS</value></param>
<param><key>label</key><value>Preset Bands</value></param>
<param><key>num_opts</key><value>5</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>option2</key><value>2</value></param>
<param><key>option3</key><value>3</value></param>
<param><key>option4</key><value>4</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>bb_gain0</key><value>0</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>0</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>freq</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>fft_size</value></param>
<param><key>name</key><value>Band Analysis</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>tfm_logpowerfft_win</key>
<param><key>id</key><value>tfm_logpowerfft_win_0</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>vector_length</key><value>fft_size</value></param>
</block>
<block>
<key>tfm_power_comparator_ff</key>
<param><key>id</key><value>tfm_power_comparator_ff_0</value></param>
<param><key>center_frequency</key><value>freq</value></param>
<param><key>directory</key><value>directory</value></param>
<param><key>diff_fixed_db</key><value>gui_mode_value</value></param>
<param><key>mode</key><value>1</value></param>
<param><key>diff_percentage</key><value>gui_mode_value</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>vector_length</key><value>fft_size</value></param>
</block>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>tfm_logpowerfft_win_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>tfm_logpowerfft_win_0</source_block_id><sink_block_id>tfm_power_comparator_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
